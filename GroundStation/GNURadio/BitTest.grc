<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>64000</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>15</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>rtlsdr_source_c</key>
<param><key>id</key><value>rtlsdr_source_c_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>960e3</value></param>
<param><key>freq0</key><value>437.24e6</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>26</value></param>
<param><key>if_gain0</key><value>18</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>gr_char_to_float</key>
<param><key>id</key><value>gr_char_to_float_0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>sprite_correlator_cf</key>
<param><key>id</key><value>sprite_correlator_cf_0</value></param>
<param><key>prn_id</key><value>-2</value></param>
</block>
<block>
<key>sprite_correlator_cf</key>
<param><key>id</key><value>sprite_correlator_cf_0_0</value></param>
<param><key>prn_id</key><value>-1</value></param>
</block>
<block>
<key>sprite_bit_decimator_fb</key>
<param><key>id</key><value>sprite_bit_decimator_fb_0</value></param>
</block>
<block>
<key>sprite_decoder_b</key>
<param><key>id</key><value>sprite_decoder_b_0</value></param>
<param><key>filename</key><value>~/test.txt</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>100</value></param>
</block>
<block>
<key>gr_sub_xx</key>
<param><key>id</key><value>gr_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Threshold Output</value></param>
<param><key>samp_rate</key><value>samp_rate/512</value></param>
<param><key>v_scale</key><value>.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>.0002</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>sprite_soft_bit_decimator_ff</key>
<param><key>id</key><value>sprite_soft_bit_decimator_ff_0</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Soft Bit Output</value></param>
<param><key>samp_rate</key><value>samp_rate/512</value></param>
<param><key>v_scale</key><value>.5</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>.0002</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Correlator Output</value></param>
<param><key>samp_rate</key><value>samp_rate*2</value></param>
<param><key>v_scale</key><value>20</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>.0002</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>rtlsdr_source_c_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>sprite_correlator_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>sprite_correlator_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_char_to_float_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>sprite_bit_decimator_fb_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>sprite_bit_decimator_fb_0</source_block_id><sink_block_id>gr_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_correlator_cf_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_correlator_cf_0_0</source_block_id><sink_block_id>gr_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>sprite_bit_decimator_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_bit_decimator_fb_0</source_block_id><sink_block_id>sprite_decoder_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sub_xx_0</source_block_id><sink_block_id>sprite_soft_bit_decimator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_soft_bit_decimator_ff_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
